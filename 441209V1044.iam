# Autodesk Inventor assembly: 441209V1044
## iProperties
Created: 2014-12
Part Number: 441209V1044
Document SubType Name: Assembly
Designer: elite
Author: elite
